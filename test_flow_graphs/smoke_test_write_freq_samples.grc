options:
  parameters:
    generate_options: no_gui
    id: smoke_test_write_freq_samples
    output_language: python
    title: smoke_test_write_freq_samples
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 256e5
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: iqtlabs_write_freq_samples_0
  id: iqtlabs_write_freq_samples
  parameters:
    sdir: '"/tmp"'
    prefix: '"samples"'
    skip_tune_step_samples: '2'
    tag: '"rx_freq"'
    vlen: '1024'
    itemsize: '8'
    write_step_samples: '128'
    samp_rate: int(samp_rate)
    rotate_secs: '3600'
    gain: '25'
    sigmf: '1'
    zstd: '1'
    rotate: '1'
    description: '""'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: 100e6
    dev_addr: driver=ettus
    gain0: '0'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', iqtlabs_write_freq_samples_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
