options:
  parameters:
    generate_options: no_gui
    id: smoke_test_tuneable_test_source
    output_language: python
    title: smoke_test_tuneable_test_source
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: iqtlabs_tuneable_test_source_0
  id: iqtlabs_tuneable_test_source
  parameters:
    freq: '0'
    freq_divisor: 1e9
  states: {}

connections:
- [blocks_throttle_0, '0', blocks_null_sink_0, '0']
- [iqtlabs_tuneable_test_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
